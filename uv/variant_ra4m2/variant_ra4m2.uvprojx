# Keil uVision project variant_ra4m2.uvprojx, settings and files
target RTOS_ThreadX (ARM-ADS)
  device: R7FA4M2AD3CFP Renesas
  pack: Renesas.RA_DFP.3.6.0
  cpu: IRAM(0x20000000,0x020000) IROM(0x00000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: MyVariant.hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group RTD
    ../../ext/rtos/rtd/: rtd_stack_monitor.c rtd_time_monitor.c real_time_dispatcher.c rtd_timer.c
  group OS
    ../../ext/rtos/os/: rtos_initialize_high_level.c rtos_initialize_low_level.c rtos_power_management.c rtos_interrupts.c rtos_kernel_enter.c rtos_rtd_mapping.c rtos_msg_queue.c rtos_ref_queue.c rtos_mailbox.c rtos_mutex.c rtos_futex.c rtos_semaphore.c rtos_system_time.c rtos_thread.c rtos_timer.c
  group common
    ../../common/prog/ped_fw/basic/: main.c
  group APP
    ../../app/variant_ra4m2/prog/rtos/rtd/: real_time_dispatcher_cfg.c
    ../../app/variant_ra4m2/prog/rtos/os/: rtos_interrupts_cfg.c rtos_services_cfg.c
    ../../app/variant_ra4m2/prog/ped_fw/basic/: basicXs.c
    ../../app/variant_ra4m2/prog/ped_fw/basic/ra4/: basicMcXs.c
    ../../app/variant_ra4m2/prog/ped_fw/timer/: timerXS.c
    ../../app/variant_ra4m2/prog/ped_fw/timer/ra4/: timerMcXs.c
