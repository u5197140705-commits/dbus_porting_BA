# Keil uVision project variant_mkv56f1.uvprojx, settings and files
target RTOS_ThreadX (ARM-ADS)
  device: MKV56F1M0VLL24 NXP
  pack: NXP.MKV56F24_DFP.12.2.0
  cpu: IRAM(0x18000000,0x1000) IRAM2(0x20000000,0x020000) IROM(0x10000000,0x100000) XRAM(0x00000000,0x010000) XRAM2(0x2f000000,0x010000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: MyVariant.hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x10000000 size 0x100000
  memory RVCT6: RAM 0x0 size 0x10000
  memory RVCT7: RAM 0x2f000000 size 0x10000
  memory RVCT9: RAM 0x18000000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group RTD
    ../../ext/rtos/rtd/: rtd_stack_monitor.c rtd_time_monitor.c real_time_dispatcher.c rtd_timer.c
  group OS
    ../../ext/rtos/os/: rtos_initialize_high_level.c rtos_initialize_low_level.c rtos_power_management.c rtos_interrupts.c rtos_kernel_enter.c rtos_rtd_mapping.c rtos_msg_queue.c rtos_ref_queue.c rtos_mailbox.c rtos_mutex.c rtos_futex.c rtos_semaphore.c rtos_system_time.c rtos_thread.c rtos_timer.c
  group common
    ../../common/prog/ped_fw/basic/: main.c
  group APP
    ../../app/variant_mkv56f1/prog/rtos/rtd/: real_time_dispatcher_cfg.c
    ../../app/variant_mkv56f1/prog/rtos/os/: rtos_interrupts_cfg.c rtos_services_cfg.c
    ../../app/variant_mkv56f1/prog/ped_fw/basic/: basicXs.c
    ../../app/variant_mkv56f1/prog/ped_fw/basic/mkv5x/: basicMcXs.c
    ../../app/variant_mkv56f1/prog/ped_fw/timer/: timerXS.c
    ../../app/variant_mkv56f1/prog/ped_fw/timer/mkv5x/: timerMcXs.c
