# Keil uVision project ThreadX_cm33_ra4.uvprojx, settings and files
target RTOS_ThreadX (ARM-ADS)
  device: R7FA4M2AD3CFP Renesas
  pack: Renesas.RA_DFP.3.6.0
  cpu: IRAM(0x20000000,0x020000) IROM(0x00000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: MyVariant.hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group RTD
    ../../ext/rtos/rtd/cfg_templates/: real_time_dispatcher_cfg.c
    ../../ext/rtos/rtd/: real_time_dispatcher.c rtd_time_monitor.c
  group OS
    ../../ext/rtos/os/: rtos_initialize_low_level.c rtos_interrupts.c rtos_kernel_enter.c rtos_mapping.c rtos_time_monitor.c
  group common
    ../../common/prog/ped_fw/basic/: main.c
  group APP
    ../../app/variant_cm33_ra4/prog/rtos/rtd/: real_time_dispatcher_cfg.c
    ../../app/variant_cm33_ra4/prog/rtos/os/: rtos_services_cfg.c
    ../../app/variant_cm33_ra4/prog/ped_fw/basic/: basicXs.c
    ../../app/variant_cm33_ra4/prog/ped_fw/basic/ra4/: basicMcXs.c
