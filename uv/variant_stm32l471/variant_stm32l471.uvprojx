# Keil uVision project variant_stm32l471.uvprojx, settings and files
target RTOS_ThreadX (ARM-ADS)
  device: STM32L471VETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: MyVariant.hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group RTD
    ../../ext/rtos/rtd/: rtd_stack_monitor.c rtd_time_monitor.c real_time_dispatcher.c rtd_timer.c
  group OS
    ../../ext/rtos/os/: rtos_initialize_high_level.c rtos_initialize_low_level.c rtos_power_management.c rtos_interrupts.c rtos_kernel_enter.c rtos_rtd_mapping.c rtos_msg_queue.c rtos_ref_queue.c rtos_mailbox.c rtos_mutex.c rtos_futex.c rtos_semaphore.c rtos_system_time.c rtos_thread.c rtos_timer.c
  group common
    ../../common/prog/ped_fw/basic/: main.c
  group APP
    ../../app/variant_stm32l471/prog/rtos/rtd/: real_time_dispatcher_cfg.c
    ../../app/variant_stm32l471/prog/rtos/os/: rtos_interrupts_cfg.c rtos_services_cfg.c
    ../../app/variant_stm32l471/prog/ped_fw/basic/: basicXs.c
    ../../app/variant_stm32l471/prog/ped_fw/basic/stm32l4/: basicMcXs.c
    ../../app/variant_stm32l471/prog/ped_fw/timer/: timerXS.c
    ../../app/variant_stm32l471/prog/ped_fw/timer/stm32l4/: timerMcXs.c
