# Keil uVision project ThreadX_cm0p_stm32g0.uvprojx, settings and files
target RTOS_ThreadX (ARM-ADS)
  device: STM32G071CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00009000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: MyVariant.hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group RTD
    ../../ext/rtos/rtd/cfg_templates/: real_time_dispatcher_cfg.c
    ../../ext/rtos/rtd/: real_time_dispatcher.c rtd_time_monitor.c
  group OS
    ../../ext/rtos/os/: rtos_initialize_low_level.c rtos_interrupts.c rtos_kernel_enter.c rtos_mapping.c rtos_time_monitor.c
  group common
    ../../common/prog/ped_fw/basic/: main.c
  group APP
    ../../app/variant_cm0p_stm32g0/prog/rtos/rtd/: real_time_dispatcher_cfg.c
    ../../app/variant_cm0p_stm32g0/prog/rtos/os/: rtos_services_cfg.c
    ../../app/variant_cm0p_stm32g0/prog/ped_fw/basic/: basicXs.c
    ../../app/variant_cm0p_stm32g0/prog/ped_fw/basic/stm32g0/: basicMcXs.c
    ../../app/variant_cm0p_stm32g0/prog/ped_fw/timer/: timerXS.c
