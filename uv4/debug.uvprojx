# Keil uVision project debug.uvprojx, settings and files
target Default (ARM-ADS)
  device: STM32L431VCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MV.hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group service
    ../app/prog/app_modules/service/Buffers/: Array.c FIFO.c LIFO.c
    ../app/prog/app_modules/service/Casts/: Casts.c
    ../app/prog/app_modules/service/CommunicationService/: CommunicationServices.c CommunicationServices_config.c CommunicationServices_param.c
    ../app/prog/app_modules/service/CRC/: CRC.c
    ../app/prog/app_modules/service/Filters/: Filters.c
    ../app/prog/app_modules/service/Mathematics/: Absolute.c Addition.c Division.c FixPointArithmetic.c Interpolation.c Multiplication.c Saturation.c Subtraction.c
  group process
    ../app/prog/app_modules/process/BrewProcess/: pBrew.c pBrew_config.c pBrew_param.c
    ../app/prog/app_modules/process/CPMManager/: CPMManager.c CPMManager_config.c CPMManager_param.c
  group controller
    ../app/prog/app_modules/controller/BrewUnitController/: BrewUnitController.c BrewUnitController_config.c BrewUnitController_param.c
    ../app/prog/app_modules/controller/FluidController/: FluidController.c FluidController_config.c FluidController_param.c
    ../app/prog/app_modules/controller/HeaterController/: HeaterController.c HeaterController_config.c HeaterController_param.c
    ../app/prog/app_modules/controller/MultiwayValveController/: MultiwayValveController.c MultiwayValveController_config.c MultiwayValveController_param.c
    ../app/prog/app_modules/controller/PowderController/: PowderController.c PowderController_config.c PowderController_param.c
    ../app/prog/app_modules/controller/TimerController/: TimerController.c TimerController_config.c TimerController_param.c
    ../app/prog/app_modules/controller/WaterSupplyController/: WaterSupplyController.c WaterSupplyController_config.c WaterSupplyController_param.c
  group driver
    ../app/prog/app_modules/driver/DCMotor/: DCMotor.c DCMotor_config.c DCMotor_param.c
    ../app/prog/app_modules/driver/Encoder/: Encoder.c Encoder_config.c Encoder_param.c
    ../app/prog/app_modules/driver/Flowmeter/: Flowmeter.c Flowmeter_config.c Flowmeter_param.c
    ../app/prog/app_modules/driver/Heater/: Heater.c Heater_config.c Heater_param.c
    ../app/prog/app_modules/driver/Pump/: Pump.c Pump_config.c Pump_param.c
    ../app/prog/app_modules/driver/Switches/: Switches.c Switches_config.c Switches_param.c
    ../app/prog/app_modules/driver/TemperatureSensor/: TemperatureSensor.c TemperatureSensor_config.c TemperatureSensor_param.c
  group cpmal
    ../app/prog/app_modules/cpmal/CAI/: cai_config.c
    ../app/prog/app_modules/cpmal/CDBUS/: CDBUS.c CDBUS_config.c
    ../app/prog/app_modules/cpmal/CDI/: CDI.c CDI_config.c CDI_param.c
    ../app/prog/app_modules/cpmal/CDO/: CDO.c CDO_config.c
    ../app/prog/app_modules/cpmal/CHBridge/: CHBridge.c CHBridge_config.c DRV8702-Q1.c DRV8702-Q1_config.c DRV8801.c DRV8801_config.c
    ../app/prog/app_modules/cpmal/CNVM/: CNVM.c CNVM_config.c EEPROM.c EEPROM_config.c
    ../app/prog/app_modules/cpmal/CPC/: CPC.c CPC_config.c
    ../app/prog/app_modules/cpmal/CPDB/: CPDB.c CPDB_config.c
    ../app/prog/app_modules/cpmal/CPG/: CPG.c CPG_config.c
    ../app/prog/app_modules/cpmal/CPS/: CPS.c CPS_config.c
    ../app/prog/app_modules/cpmal/CPWM/: CPWM.c CPWM_config.c
    ../app/prog/app_modules/cpmal/CPower/: CPower.c CPower_config.c
    ../app/prog/app_modules/ecu/NVM/: eNVM.c eEEPROM.c
  group ucal
    ../app/prog/app_modules/ucal/UADC/: UADC.c UADC_config.c
    ../app/prog/app_modules/ucal/UClock/: UClock.c
    ../app/prog/app_modules/ucal/UDAC/: UDAC.c
    ../app/prog/app_modules/ucal/UDBG/: UDBG.c UDBG_config.c
    ../app/prog/app_modules/ucal/UDMA/: UDMA.c
    ../app/prog/app_modules/ucal/UGPIO/: UGPIO.c UGPIO_config.c
    ../app/prog/app_modules/ucal/UI2C/: UI2C.c
    ../app/prog/app_modules/ucal/UPS/: UPS.c
    ../app/prog/app_modules/ucal/UPWM/: UPWM.c
    ../app/prog/app_modules/ucal/UPower/: UPower.c
  group New Group
    ./ext/rtos/os/: rtos_initialize_low_level.c rtos_interrupts.c rtos_kernel_enter.c
    ./ext/rtos/rtd/: real_time_dispatcher.c rtd_time_monitor.c
    ./ext/rtos/rtd/eds/: event_driven_scheduler.c
